
FILESEXTRAPATHS_append := "${THISDIR}/opkg/"

PE = "2"

SRC_URI += "\
           file://opkg.conf \           
"