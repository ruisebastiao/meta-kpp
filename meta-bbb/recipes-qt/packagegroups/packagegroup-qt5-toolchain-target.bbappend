
RDEPENDS_${PN} += " \
        libgles-omap3 \
        libgles-omap3-dev \
"
DISTRO_FEATURES_remove = "x11 wayland"