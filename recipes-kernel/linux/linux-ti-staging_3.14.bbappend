BRANCH = "master"

SRC_URI = "git:///home/automacao/yocto/poky/beagleboard-linux-bare.git/;protocol=file;bareclone=1;branch=${BRANCH},meta;name=machine,meta"
