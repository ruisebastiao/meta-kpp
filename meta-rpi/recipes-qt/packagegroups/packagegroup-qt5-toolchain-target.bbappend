
RDEPENDS_${PN} += " \
        vc-graphics \
        vc-graphics-dev \
"
