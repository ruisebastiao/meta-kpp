SUMMARY = "A Qt5 image for raspberry pi"

LICENSE = "CLOSED"


IMAGE_INSTALL += "\
		rpi-config \
		"
