PACKAGECONFIG[gles2] = "-opengl es2,,virtual/libgles2 virtual/egl"
PACKAGECONFIG[eglfs] = "-eglfs,-no-eglfs,eglfs"
