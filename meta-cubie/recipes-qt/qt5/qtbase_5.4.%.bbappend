#PACKAGECONFIG_X11 = ""
#PACKAGECONFIG_GL = ""
#PACKAGECONFIG_remove="x11"

PACKAGECONFIG_append =  " dbus evdev widgets tools libs linuxfb gles2 \
                        teststools accessibility tslib"                       