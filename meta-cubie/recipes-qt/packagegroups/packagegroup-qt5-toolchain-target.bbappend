
RDEPENDS_${PN} += " \
        sunxi-mali \
        sunxi-mali-dev \
"