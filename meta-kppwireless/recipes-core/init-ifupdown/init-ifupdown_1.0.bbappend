FILESEXTRAPATHS_append := "${THISDIR}/init-ifupdown-1.0:"

PR = "r8"

SRC_URI += "file://interfaces \
	    \
	"
