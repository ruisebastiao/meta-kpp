
QT_MODULE_BRANCH = "master"
SRC_URI = " \
    git://github.com/qtproject/qt3d.git;branch=${QT_MODULE_BRANCH} \
"
SRCREV = "${AUTOREV}"
