
RDEPENDS_${PN} += " \
    opencv-dev \
    qzxing-dev \
"

RRECOMMENDS_${PN} += " \
    qtquickcontrols-qmlplugins \
"
